## src/examples/alive_heartbeat/Kconfig
```kconfig
menuconfig EXAMPLES_alive_heartbeat
	bool "alive_heartbeat"
	default n
	---help---
		Enable support for alive_heartbeat
```
